# Keil uVision project KAR_v1.0.uvprojx, settings and files
target MM32F031K6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MM32x031 MindMotion
  pack: MindMotion.MM32x031_DFP.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   ..\output\app.axf --bin -o ..\Bin\app.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MM32F031K6
  c include: ..\app;..\MM32F0xx_library\CMSIS\KEIL_CORE;..\MM32F0xx_library\MM32F031x8\HAL_lib\inc;..\MM32F0xx_library\MM32F031x8\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x6800
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group APP
    ../app/: Abnormal_Monitoring.c config.c main.c moto.c led.c power_management.c rtc.c user_it.c user_timer.c user_uart.c test.c i2c.c
  group CORE
    ../MM32F0xx_library/MM32F031x8/Source/KEIL_StartAsm/: startup_MM32F031x8.s
    ../MM32F0xx_library/MM32F031x8/Source/: system_MM32F031x8.c
  group FWLIB
    ../MM32F0xx_library/MM32F031x8/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
software components: CMSIS:CORE 4.3.0
