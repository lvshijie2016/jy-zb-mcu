# Keil uVision project KAR_v1.0.uvprojx, settings and files
target KAR_v1.0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: KAR_v1_0 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   ..\output\KAR_v1_0.axf --bin -o ..\Bin\KAR_v1_0.bin
  c flags: Optim=1 wLevel=2
  c include: ..\C32F0xx_library\Drivers\source;..\C32F0xx_library\Drivers\include;..\C32F0xx_library\Core\CM0\DeviceSupport\C32F0xx\startup\arm;..\C32F0xx_library\Core\CM0\CoreSupport;..\C32F0xx_library\Core\CM0\DeviceSupport\C32F0xx;..\user_lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group USER
    ../user/: main.c config.c user_it.c user_timer.c user_uart.c led.c rtc.c moto.c power_management.c Abnormal_Monitoring.c
  group CORE
    ../C32F0xx_library/Core/CM0/DeviceSupport/C32F0xx/startup/arm/: startup_c32f0xx_s.s
    ../C32F0xx_library/Core/CM0/DeviceSupport/C32F0xx/: system_c32f0xx.c
  group FWLIB
    ../C32F0xx_library/Drivers/source/: c32f0xx_sys.c c32f0xx_gpio.c c32f0xx_iap.c c32f0xx_iic.c c32f0xx_pwm.c c32f0xx_timer.c c32f0xx_uart.c c32f0xx_adc.c c32f0xx_wdt.c
software components: CMSIS:CORE 4.3.0
