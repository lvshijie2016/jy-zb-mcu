# Keil uVision project IAP_v3.0.uvprojx, settings and files
target IAP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MM32F031K8U MindMotion
  pack: MindMotion.MM32F031_DFP.1.3.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IAP_v3.0
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MM32F0xx_library\CMSIS\KEIL_CORE;..\MM32F0xx_library\MM32F031x8\Include;..\MM32F0xx_library\MM32F031x8\HAL_lib\inc;..\iap
  memory RVCT4: ROM 0x8000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../MM32F0xx_library/MM32F031x8/Source/: system_MM32F031x8.c
    ../MM32F0xx_library/MM32F031x8/Source/KEIL_StartAsm/: startup_MM32F031x8.s
  group HALlib
    ../MM32F0xx_library/MM32F031x8/HAL_lib/src/: HAL_flash.c HAL_gpio.c HAL_misc.c HAL_rcc.c HAL_uart.c
  group USER
    ../iap/: config.c main.c user_uart.c
