# Keil uVision project KAR_v1.0.uvproj, settings and files
target KAR_v1.0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: iap +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   ..\output\iap.axf --bin -o ..\Bin\iap.bin
  c flags: Optim=1 wLevel=2
  c include: ..\C32F0xx_library\Drivers\source;..\C32F0xx_library\Drivers\include;..\C32F0xx_library\Core\CM0\DeviceSupport\C32F0xx\startup\arm;..\C32F0xx_library\Core\CM0\CoreSupport;..\C32F0xx_library\Core\CM0\DeviceSupport\C32F0xx;..\iap
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group IAP
    ../iap/: user_uart.c config.c main.c
  group CORE
    ../C32F0xx_library/Core/CM0/DeviceSupport/C32F0xx/startup/arm/: startup_c32f0xx_s.s
    ../C32F0xx_library/Core/CM0/DeviceSupport/C32F0xx/: system_c32f0xx.c
  group FWLIB
    ../C32F0xx_library/Drivers/source/: c32f0xx_sys.c c32f0xx_gpio.c c32f0xx_iap.c c32f0xx_iic.c c32f0xx_pwm.c c32f0xx_timer.c c32f0xx_uart.c c32f0xx_adc.c c32f0xx_wdt.c
